# Keil uVision project chassis_task.uvprojx, settings and files
target chassis_task (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: chassis_task +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__FPU_USED=1U,__FPU_PRESENT=1U,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../bsp/boards;../application;../components/algorithm;../components/algorithm/Include;../components/controller;../components/devices;../components/UI;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../components/filter
  asm include: ..\\Inc;../Inc;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c gpio.c freertos.c adc.c can.c dma.c i2c.c rtc.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group application
    ../application/: chassis_task.c gimbal_task.c gimbal_task.h INS_task.c led_flow_task.c shoot.c shoot.h uart_receive.c uart_receive.h CAN_receive.c calibrate_task.c chassis_behaviour.c detect_task.c remote_control.c test_task.c vofa.h vofa.c referee.c referee.h referee_usart_task.c referee_usart_task.h Chassis_power_control.c Chassis_power_control.h set_power_task.c set_power_task.h Can_task.c Can_task.h voltage_task.c voltage_task.h oled_task.c oled_task.h protocol.h
  group UI
    ../components/UI/: ui_default_Ungroup_0.c ui_default_Ungroup_0.h ui_interface.c ui_interface.h ui_types.h ui_default_Ungroup_1.c ui_default_Ungroup_1.h ui_default_Ungroup_2.c ui_default_Ungroup_2.h ui.h ui_default_Ungroup_3.c ui_default_Ungroup_3.h ui_default_Ungroup_4.c ui_default_Ungroup_4.h ui_default_Ungroup_5.c ui_default_Ungroup_5.h
  group filter
    ../components/filter/: balance_filter.c balance_filter.h
  group devices
    ../components/devices/: BMI088driver.c BMI088Middleware.c ist8310driver.c ist8310driver_middleware.c OLED.c OLED.h oledfont.h
  group algorithm
    ../components/algorithm/: AHRS_middleware.c user_lib.c AHRS.lib arm_cortexM4lf_math.lib CRC8_CRC16.c CRC8_CRC16.h fifo.c fifo.h LQR.c LQR.h kalman_filter.c kalman_filter.h
  group controller
    ../components/controller/: pid.c
  group boards
    ../bsp/boards/: bsp_buzzer.c bsp_can.c bsp_delay.c bsp_flash.c bsp_imu_pwm.c bsp_led.c bsp_rc.c bsp_spi.c bsp_usart.c bsp_usart.h bsp_adc.c bsp_adc.h bsp_i2c.c bsp_i2c.h
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Middlewares/FreeRTOS
    ../components/UI/: ui.h
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
software components: CMSIS:CORE 5.0.1, Compiler:Event Recorder 1.1.0
